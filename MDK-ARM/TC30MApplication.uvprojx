# Keil uVision project TC30MApplication.uvprojx, settings and files
target TC30MApplication (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F091RC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: TC30MApplication
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F091xC
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;..\Test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_gpio.c stm32f0xx_hal_cortex.c stm32f0xx_hal_flash.c stm32f0xx_hal_tim.c stm32f0xx_hal.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_adc.c stm32f0xx_hal_i2c.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_pwr.c stm32f0xx_hal_uart.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_rcc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Application/User
    ../Src/: rtc.c usart.c main.c i2c.c gpio.c stm32f0xx_it.c stm32f0xx_hal_msp.c tim.c iwdg.c adc.c dma.c appatprocess.c atcmd.c atcmd_def.c deepsleep.c eventmsgque_process.c initialization.c iocontrol.c iqmgr.c limifsm.c ltecatm.c network.c parseatat.c pwmaudio.c rtcclock.c sendatcmd.c spi_driver.c uart_api.c ublox_driver.c usrtimer.c version.c flash.c lis3dh_driver.c wedgemsgque.c wedgertctimer.c wedgedeviceinfo.c wedgeapplication.c wedgeeventalertflow.c
  group Application/MDK-ARM
    ./: startup_stm32f091xc.s
  group Test
    ../Test/: wedgetest.c wedgemsgquetest.c wedgertctimertest.c wedgepowerlosttest.c wedgedeviceinfotest.c
software components: CMSIS:CORE 4.1.0
